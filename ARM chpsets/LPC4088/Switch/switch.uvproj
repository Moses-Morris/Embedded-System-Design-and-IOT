# Keil uVision project switch.uvproj, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: LPC4088 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: switch
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  group Source Group 1
    ./: startup_LPC407x_8x_177x_8x.s switch.c
