# Keil uVision project LPC4088.uvproj, settings and files
target Target 1 (MCS-51)
  device: LPC47N252 SMSC
  cpu: IRAM(0-0xFF) CLOCK(12000000)
  output: LPC4088
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LCP4088.c
